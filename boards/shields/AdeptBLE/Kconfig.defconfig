## boards/shields/AdeptBLE/Kconfig.defconfig
```kconfig
if SHIELD_ADEPTBLE

config ZMK_KEYBOARD_NAME
    default "Magic 8"

endif

config SPI
	default y
```
